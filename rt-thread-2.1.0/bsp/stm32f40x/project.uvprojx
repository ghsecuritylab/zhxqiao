# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;..\..\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
    ./: rtconfig.h
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c gpio.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group userDRIVER
    ../../user/drivers/: userGPIO.c usergpio.h spi1.c spi1.h usart1_app.c usart1_app.h usart2_app.c usart2_app.h
  group userAPP
    ../../user/APPS/: TFT3_2.c TFT3_2.h W25Q128FVSIGTR.c W25Q128FVSIGTR.h
  group userAgreement
    ../../user/agreement/: 7b7dxieyi.c 7b7dxieyi.h APPxieyi.c APPxieyi.h HLY_testtool.c hly_testtool.h IAPxieyi.c IAPxieyi.h
  group userParameter
    ../../user/parameter/: parameter.c parameter.h
  group userTools
    ../../user/tools/: crc16.c crc16.h delay.c delay.h lc-switch.h drv_key.c drv_key.h
  group user
    ../../user/: SYS.c SYS.h users.h
  group gui
    ../../components/gui/src/: asc12font.c asc16font.c blit.c box.c color.c container.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c dc_rotozoom.c dc_trans.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c hz12font.c hz16font.c image.c image_bmp.c image_hdc.c image_jpg.c image_png.c image_xpm.c matrix.c mouse.c region.c rtgui_app.c rtgui_driver.c rtgui_object.c rtgui_system.c server.c title.c topwin.c widget.c window.c
